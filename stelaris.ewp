# IAR project stelaris.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: LM4F120H5QR TexasInstruments LM4F120H5QR
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  ICCARM.CCDefines: TARGET_IS_BLIZZARD_RA2; PART_LM4F120H5QR; UART_BUFFERED
  ICCARM.CCIncludePath2: d:\GIT\stelariz; D:\GIT\stelariz\inc; D:\GIT\stelariz\modbus\include; D:\GIT\stelariz\modbus\port; D:\GIT\stelariz\modbus\rtu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: c.srec
  ILINK.IlinkOutputFile: c.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: default None
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group modbus
    modbus/: mb.c
  group modbus/inc
    modbus/include/: mb.h mbconfig.h mbframe.h mbfunc.h mbport.h mbproto.h mbutils.h
  group modbus/port
    modbus/port/: port.h portevent.c portserial.c porttimer.c
  group modbus/rtu
    modbus/rtu/: mbcrc.c mbcrc.h mbrtu.c mbrtu.h
  group src
    ./: dat_scor.c dvig.c foto.c lcd.c led.c main.c servo.c
  group sys
    ./: startup_ewarm.c
